# Keil uVision project Q1kony.uvprojx, settings and files
target Q1kony (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103V8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Q1kony +hex
  c flags: v6Lang=1 v6LangP=1
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\USER\FreeRTOSV6.1.0;.\USER\FreeRTOSV6.1.0\include;.\USER\FreeRTOSV6.1.0\portable\RVDS\ARM_CM3;.\USER\FreeRTOSV6.1.0\portable\MemMang;.\USER\MyDrv;.\USER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp&CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./USER/: system_stm32f10x.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group FreeRTOS_V_6_1_0
    ./USER/FreeRTOSV6.1.0/: croutine.c list.c queue.c tasks.c
    ./USER/FreeRTOSV6.1.0/portable/RVDS/ARM_CM3/: port.c
    ./USER/FreeRTOSV6.1.0/portable/MemMang/: heap_2.c
  group MyDRV
    ./USER/MyDrv/: delay.c LPH8731-3C.c
  group USER
    ./USER/: main.c mcu_config.c mcu_config.h stm32f10x_it.c ErrorProcessing.c FreeRTOSConfig.h motor_driver.c motor_driver.h usart.c usart.h ErrorProcessing.h quest_routines.h stm32f10x_conf.h stm32f10x_it.h terminal.h quest.h
    ./User/: quest.c
